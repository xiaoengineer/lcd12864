# Keil uVision project tmp.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: tmp +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: CHAR_CODE,
  c include: .\lib
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./lib/: lcd12864.c
